// SPDX-License-Identifier: GPL-3.0-or-later
#include "ariec61850/mms/connection_runtime.hpp"
#include "ariec61850/mms/static_dispatcher.hpp"
#include "ariec61850/mms/static_object_table.hpp"

#include <algorithm>
#include <array>
#include <cstdint>
#include <iostream>
#include <span>

namespace {
using namespace ar::iec61850;

wire::EncodeResult read_stub(const void*, std::span<std::uint8_t> destination) noexcept {
    constexpr std::array<std::uint8_t, 3> value{{0x83, 0x01, 0x00}};
    if (destination.size() < value.size()) {
        return {wire::EncodeStatus::buffer_too_small, 0U, value.size()};
    }
    std::copy(value.begin(), value.end(), destination.begin());
    return {wire::EncodeStatus::ok, value.size(), value.size()};
}

const char* status_name(mms::MmsStaticConnectionStatus status) noexcept {
    using S = mms::MmsStaticConnectionStatus;
    switch (status) {
    case S::need_more: return "need_more";
    case S::response_ready: return "response_ready";
    case S::consumed_no_response: return "consumed_no_response";
    case S::malformed_transport: return "malformed_transport";
    case S::protocol_violation: return "protocol_violation";
    case S::application_rejected: return "application_rejected";
    case S::response_buffer_too_small: return "response_buffer_too_small";
    case S::workspace_too_small: return "workspace_too_small";
    case S::peer_limit_exceeded: return "peer_limit_exceeded";
    case S::backend_failure: return "backend_failure";
    case S::closed: return "closed";
    }
    return "unknown";
}
}

int main() {
    using namespace ar::iec61850;
    constexpr std::array<std::uint8_t, 2> bool_type{{0x83, 0x00}};
    const std::array<mms::MmsStaticObjectEntry, 1> entries{{
        {"IED1LD0", "LLN0$ST$Health$stVal", bool_type, read_stub, nullptr}
    }};
    const mms::MmsStaticObjectTable table{entries};
    mms::MmsStaticDispatchPolicy dispatch_policy{};
    dispatch_policy.advertise_flattened_child_aliases = true;
    const mms::MmsStaticApplicationDispatcher dispatcher{table, dispatch_policy};
    mms::MmsStaticConnectionRuntime runtime{dispatcher};

    constexpr std::array<std::uint8_t, 22> cotp_cr{{
        0x03,0x00,0x00,0x16,0x11,0xE0,0x00,0x00,0x00,0x01,0x00,
        0xC0,0x01,0x0D,0xC2,0x02,0x00,0x01,0xC1,0x02,0x00,0x01}};
    constexpr std::array<std::uint8_t, 187> association{{
        0x03,0x00,0x00,0xBB,0x02,0xF0,0x80,0x0D,0xB2,0x05,0x06,0x13,0x01,0x00,0x16,0x01,0x02,0x14,0x02,0x00,0x02,0x33,0x02,0x00,0x01,0x34,0x02,0x00,0x01,0xC1,0x9C,0x31,0x81,0x99,0xA0,0x03,0x80,0x01,0x01,0xA2,0x81,0x91,0x81,0x04,0x00,0x00,0x00,0x01,0x82,0x04,0x00,0x00,0x00,0x01,0xA4,0x23,0x30,0x0F,0x02,0x01,0x01,0x06,0x04,0x52,0x01,0x00,0x01,0x30,0x04,0x06,0x02,0x51,0x01,0x30,0x10,0x02,0x01,0x03,0x06,0x05,0x28,0xCA,0x22,0x02,0x01,0x30,0x04,0x06,0x02,0x51,0x01,0x61,0x5E,0x30,0x5C,0x02,0x01,0x01,0xA0,0x57,0x60,0x55,0xA1,0x07,0x06,0x05,0x28,0xCA,0x22,0x02,0x03,0xA2,0x07,0x06,0x05,0x29,0x01,0x87,0x67,0x01,0xA3,0x03,0x02,0x01,0x0C,0xA6,0x06,0x06,0x04,0x29,0x01,0x87,0x67,0xA7,0x03,0x02,0x01,0x0C,0xBE,0x2F,0x28,0x2D,0x02,0x01,0x03,0xA0,0x28,0xA8,0x26,0x80,0x03,0x00,0xFD,0xE8,0x81,0x01,0x05,0x82,0x01,0x05,0x83,0x01,0x0A,0xA4,0x16,0x80,0x01,0x01,0x81,0x03,0x05,0xF1,0x00,0x82,0x0C,0x03,0xEE,0x1C,0x00,0x00,0x04,0x08,0x00,0x00,0x79,0xEF,0x18}};
    constexpr std::array<std::uint8_t, 36> get_name_list{{
        0x03,0x00,0x00,0x24,0x02,0xF0,0x80,0x01,0x00,0x01,0x00,0x61,
        0x17,0x30,0x15,0x02,0x01,0x03,0xA0,0x10,0xA0,0x0E,0x02,0x01,
        0x01,0xA1,0x09,0xA0,0x03,0x80,0x01,0x09,0xA1,0x02,0x80,0x00}};

    std::array<std::uint8_t, 65536> response{};
    std::array<std::uint8_t, 65536> workspace{};
    const auto step = [&](auto bytes, const char* name) {
        const auto result = runtime.process_tcp_window(bytes, response, workspace);
        std::cout << "P4_STATEFUL_STEP name=" << name
                  << " status=" << status_name(result.status)
                  << " state=" << static_cast<int>(result.state)
                  << " consumed=" << result.consumed_bytes
                  << " written=" << result.bytes_written
                  << " service=" << static_cast<int>(result.application_service)
                  << " invoke=" << result.invoke_id << '\n';
        return result;
    };

    const auto cr = step(std::span<const std::uint8_t>{cotp_cr}, "cotp-cr");
    if (!cr.response_ready()) return 1;
    const auto aa = step(std::span<const std::uint8_t>{association}, "association");
    if (!aa.response_ready() || runtime.state() != mms::MmsStaticConnectionState::established) return 2;
    const auto gnl = step(std::span<const std::uint8_t>{get_name_list}, "get-name-list");
    if (!gnl.response_ready()) return 3;

    std::cout << "P4_LIBIEC61850_STATEFUL_RUNTIME_PASS association=persistent discovery=response_ready\n";
    return 0;
}
