// SPDX-License-Identifier: GPL-3.0-or-later

#include "ariec61850/acse/association_span.hpp"
#include "ariec61850/osi/presentation_span.hpp"
#include "ariec61850/osi/session_span.hpp"

#include <algorithm>
#include <array>
#include <cstddef>
#include <cstdint>
#include <span>

namespace {

using namespace ar::iec61850;

constexpr std::array<std::uint8_t, 184U> kRequest{
    0x0DU, 0xB6U, 0x05U, 0x06U, 0x13U, 0x01U, 0x00U, 0x16U, 0x01U, 0x02U, 0x14U, 0x02U,
    0x00U, 0x02U, 0x33U, 0x02U, 0x00U, 0x01U, 0x34U, 0x02U, 0x00U, 0x01U, 0xC1U, 0xA0U,
    0x31U, 0x81U, 0x9DU, 0xA0U, 0x03U, 0x80U, 0x01U, 0x01U, 0xA2U, 0x81U, 0x95U, 0x81U,
    0x04U, 0x00U, 0x00U, 0x00U, 0x01U, 0x82U, 0x04U, 0x00U, 0x00U, 0x00U, 0x01U, 0xA4U,
    0x23U, 0x30U, 0x0FU, 0x02U, 0x01U, 0x01U, 0x06U, 0x04U, 0x52U, 0x01U, 0x00U, 0x01U,
    0x30U, 0x04U, 0x06U, 0x02U, 0x51U, 0x01U, 0x30U, 0x10U, 0x02U, 0x01U, 0x03U, 0x06U,
    0x05U, 0x28U, 0xCAU, 0x22U, 0x02U, 0x01U, 0x30U, 0x04U, 0x06U, 0x02U, 0x51U, 0x01U,
    0x61U, 0x62U, 0x30U, 0x60U, 0x02U, 0x01U, 0x01U, 0xA0U, 0x5BU, 0x60U, 0x59U, 0xA1U,
    0x07U, 0x06U, 0x05U, 0x28U, 0xCAU, 0x22U, 0x02U, 0x03U, 0xA2U, 0x07U, 0x06U, 0x05U,
    0x29U, 0x01U, 0x87U, 0x67U, 0x01U, 0xA3U, 0x03U, 0x02U, 0x01U, 0x0CU, 0xA6U, 0x06U,
    0x06U, 0x04U, 0x29U, 0x01U, 0x87U, 0x67U, 0xA7U, 0x03U, 0x02U, 0x01U, 0x0CU, 0xBEU,
    0x33U, 0x28U, 0x31U, 0x06U, 0x02U, 0x51U, 0x01U, 0x02U, 0x01U, 0x03U, 0xA0U, 0x28U,
    0xA8U, 0x26U, 0x80U, 0x03U, 0x00U, 0xFDU, 0xE8U, 0x81U, 0x01U, 0x0AU, 0x82U, 0x01U,
    0x0AU, 0x83U, 0x01U, 0x05U, 0xA4U, 0x16U, 0x80U, 0x01U, 0x01U, 0x81U, 0x03U, 0x05U,
    0xF1U, 0x00U, 0x82U, 0x0CU, 0x03U, 0xEEU, 0x1CU, 0x00U, 0x00U, 0x04U, 0x08U, 0x00U,
    0x00U, 0x79U, 0xEFU, 0x18U};

constexpr std::array<std::uint8_t, 138U> kResponse{
    0x0EU, 0x88U, 0x05U, 0x06U, 0x13U, 0x01U, 0x00U, 0x16U, 0x01U, 0x02U, 0x14U, 0x02U,
    0x00U, 0x02U, 0x33U, 0x02U, 0x00U, 0x01U, 0x34U, 0x02U, 0x00U, 0x01U, 0xC1U, 0x72U,
    0x31U, 0x70U, 0xA0U, 0x03U, 0x80U, 0x01U, 0x01U, 0xA2U, 0x69U, 0xA5U, 0x12U, 0x30U,
    0x07U, 0x80U, 0x01U, 0x00U, 0x81U, 0x02U, 0x51U, 0x01U, 0x30U, 0x07U, 0x80U, 0x01U,
    0x00U, 0x81U, 0x02U, 0x51U, 0x01U, 0x61U, 0x53U, 0x30U, 0x51U, 0x02U, 0x01U, 0x01U,
    0xA0U, 0x4CU, 0x61U, 0x4AU, 0xA1U, 0x07U, 0x06U, 0x05U, 0x28U, 0xCAU, 0x22U, 0x02U,
    0x03U, 0xA2U, 0x03U, 0x02U, 0x01U, 0x00U, 0xA3U, 0x05U, 0xA1U, 0x03U, 0x02U, 0x01U,
    0x00U, 0xBEU, 0x33U, 0x28U, 0x31U, 0x06U, 0x02U, 0x51U, 0x01U, 0x02U, 0x01U, 0x03U,
    0xA0U, 0x28U, 0xA9U, 0x26U, 0x80U, 0x03U, 0x00U, 0xFDU, 0xE8U, 0x81U, 0x01U, 0x0AU,
    0x82U, 0x01U, 0x0AU, 0x83U, 0x01U, 0x05U, 0xA4U, 0x16U, 0x80U, 0x01U, 0x01U, 0x81U,
    0x03U, 0x05U, 0xF1U, 0x00U, 0x82U, 0x0CU, 0x03U, 0xEEU, 0x1CU, 0x00U, 0x00U, 0x04U,
    0x08U, 0x00U, 0x00U, 0x79U, 0xEFU, 0x18U};

constexpr std::array<std::uint8_t, 5U> kMmsApplicationContext{
    0x28U, 0xCAU, 0x22U, 0x02U, 0x03U};
constexpr std::array<std::uint8_t, 5U> kCalledApTitle{
    0x29U, 0x01U, 0x87U, 0x67U, 0x01U};
constexpr std::array<std::uint8_t, 4U> kCallingApTitle{
    0x29U, 0x01U, 0x87U, 0x67U};
constexpr std::array<std::uint8_t, 2U> kBerSyntax{0x51U, 0x01U};

template <std::size_t N>
[[nodiscard]] bool matches(
    const std::span<const std::uint8_t> actual,
    const std::array<std::uint8_t, N>& expected) noexcept {
    return actual.size() == expected.size() &&
        std::equal(actual.begin(), actual.end(), expected.begin());
}

} // namespace

int main() {
    acse::AssociationRequestView request;
    if (!acse::AcseSpanCodec::try_decode_association_request_view(kRequest, request)) {
        return 1;
    }

    if (request.session.kind != osi::SessionWireKind::connect ||
        request.presentation.mode_selector != 1U ||
        request.presentation.context_count != 2U ||
        request.acse_presentation_context_id != 1U ||
        request.mms_presentation_context_id != 3U ||
        !matches(request.aarq.application_context_name, kMmsApplicationContext) ||
        !matches(request.aarq.called_ap_title, kCalledApTitle) ||
        !request.aarq.called_ae_qualifier.has_value() ||
        *request.aarq.called_ae_qualifier != 12U ||
        !matches(request.aarq.calling_ap_title, kCallingApTitle) ||
        !request.aarq.calling_ae_qualifier.has_value() ||
        *request.aarq.calling_ae_qualifier != 12U ||
        !matches(request.aarq.user_information.direct_reference, kBerSyntax) ||
        request.aarq.user_information.indirect_reference != 3U ||
        !matches(
            request.aarq.user_information.single_asn1_type,
            std::array<std::uint8_t, 40U>{
                0xA8U, 0x26U,
                0x80U, 0x03U, 0x00U, 0xFDU, 0xE8U,
                0x81U, 0x01U, 0x0AU,
                0x82U, 0x01U, 0x0AU,
                0x83U, 0x01U, 0x05U,
                0xA4U, 0x16U,
                0x80U, 0x01U, 0x01U,
                0x81U, 0x03U, 0x05U, 0xF1U, 0x00U,
                0x82U, 0x0CU, 0x03U, 0xEEU, 0x1CU, 0x00U, 0x00U, 0x04U,
                0x08U, 0x00U, 0x00U, 0x79U, 0xEFU, 0x18U})) {
        return 2;
    }

    std::uint32_t acse_context{};
    std::uint32_t mms_context{};
    if (!request.presentation.try_context_id_for_abstract_syntax(
            osi::PresentationSpanCodec::acse_abstract_syntax_name(), acse_context) ||
        !request.presentation.try_context_id_for_abstract_syntax(
            osi::PresentationSpanCodec::mms_abstract_syntax_name(), mms_context) ||
        acse_context != 1U || mms_context != 3U) {
        return 3;
    }

    std::array<std::uint8_t, 512U> response{};
    const auto required = acse::AcseSpanCodec::accept_response_size(request);
    const auto result = acse::AcseSpanCodec::build_accept_response_into(request, response);
    if (!required || *required != kResponse.size() ||
        !result.success() || result.bytes_written != kResponse.size() ||
        !matches(
            std::span<const std::uint8_t>{response}.first(result.bytes_written),
            kResponse)) {
        return 4;
    }

    // Confirm the deterministic AARE itself is stable and contains the expected
    // MMS Initiate response used by the host association profile.
    std::array<std::uint8_t, 128U> aare{};
    const auto aare_result = acse::AcseSpanCodec::encode_default_accept_aare_into(aare);
    if (!aare_result.success() ||
        aare_result.bytes_written != acse::AcseSpanCodec::default_accept_aare_size() ||
        !matches(
            acse::AcseSpanCodec::default_mms_initiate_response(),
            std::array<std::uint8_t, 40U>{
                0xA9U, 0x26U,
                0x80U, 0x03U, 0x00U, 0xFDU, 0xE8U,
                0x81U, 0x01U, 0x0AU,
                0x82U, 0x01U, 0x0AU,
                0x83U, 0x01U, 0x05U,
                0xA4U, 0x16U,
                0x80U, 0x01U, 0x01U,
                0x81U, 0x03U, 0x05U, 0xF1U, 0x00U,
                0x82U, 0x0CU, 0x03U, 0xEEU, 0x1CU, 0x00U, 0x00U, 0x04U,
                0x08U, 0x00U, 0x00U, 0x79U, 0xEFU, 0x18U})) {
        return 5;
    }

    // Association setup is not a realtime hot path, but repeated construction
    // still proves the bounded responder does not require owning protocol trees.
    for (std::uint32_t iteration = 0U; iteration < 10'000U; ++iteration) {
        const auto repeated = acse::AcseSpanCodec::build_accept_response_into(
            request, response);
        if (!repeated.success() || repeated.bytes_written != kResponse.size() ||
            response[0] != osi::SessionSpanCodec::accept_code ||
            response[1] != 0x88U) {
            return 6;
        }
    }

    constexpr std::array<std::uint8_t, 4U> malformed{
        0x0DU, 0x02U, 0xC1U, 0x00U};
    acse::AssociationRequestView rejected;
    if (acse::AcseSpanCodec::try_decode_association_request_view(malformed, rejected)) {
        return 7;
    }

    return 0;
}
